# Keil uVision project USART.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: -cpp11
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\SERVO;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.cpp stm32f10x_it.cpp system_stm32f10x.cpp
  group HARDWARE
    ../HARDWARE/KEY/: key.cpp
    ../HARDWARE/LED/: led.cpp
    ../HARDWARE/SERVO/: servo.cpp
    ../HARDWARE/RS485/: rs485.cpp
    ../HARDWARE/ADC/: adc.cpp
  group SYSTEM
    ../SYSTEM/delay/: delay.cpp
    ../SYSTEM/sys/: sys.cpp
    ../SYSTEM/usart/: usart.cpp
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.cpp
  group FWLib
    ../STM32F10x_FWLib/src/: misc.cpp stm32f10x_gpio.cpp stm32f10x_rcc.cpp stm32f10x_usart.cpp stm32f10x_adc.cpp
